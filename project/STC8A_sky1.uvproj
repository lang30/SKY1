# Keil uVision project STC8A_sky1.uvproj, settings and files
target STC8A_SKY1c (MCS-51)
  device: STC8A8K64S4A12 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFF8) CLOCK(35000000) MODP2
  output: STC8A_SKY1c +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\user;..\app;..\app\xrcore;..\app\HARDWARE;..\Driver;..\Driver\inc;..\lib
  link misc: REMOVEUNUSED
  group user
    ../user/: Main.c
  group app
    ../app/: STC8A_led.c
  group XRcore
    ../app/xrcore/: WCM.c beep.c Seglcd.c
  group Hardware
    ../app/HARDWARE/HT1621/: STC8A_HT1621.c
  group driver
    ../Driver/: STC8A_init.c STC8x_SYSCLK.c
    ../Driver/src/: STC8A_UART.c STC8A_NVIC.c STC8A_I2C.c STC8A_GPIO.c STC8A_SPI.c STC8A_Exti.c STC8A_Delay.c STC8A_Timer.c
